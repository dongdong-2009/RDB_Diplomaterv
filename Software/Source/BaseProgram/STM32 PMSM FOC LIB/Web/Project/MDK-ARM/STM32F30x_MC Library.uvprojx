# Keil uVision project STM32F30x_MC Library.uvprojx, settings and files
target STM32F303 Single Drive (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: MC_Library_STM32F303_single_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X, MC_LIBRARY_SINGLE, ARM_MATH_CM4, CCMRAM
  c include: ..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F30x\Include;..\..\..\Common\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\Project;"..\..\MCLibrary";"..\..\MCLibrary\inc";"..\..\MCLibrary\interface";"..\..\MCLibrary\interface\common"
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group MCLibrary_interface common
    ../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h RampExtMngrClass.h
  group MCLibrary_interface
    ../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h MotorPowerMeasurementClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h ICS_F30X_PWMnCurrFdbkClass.h R1_F30X_PWMnCurrFdbkClass.h R3_1_F30X_PWMnCurrFdbkClass.h R3_2_F30X_PWMnCurrFdbkClass.h R3_4_F30X_PWMnCurrFdbkClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h MTPACtrlClass.h OpenLoopClass.h OneTouchTuningClass.h SelfComCtrlClass.h
  group MCLibrary_private
    ../../MCLibrary/inc/: BusVoltageSensorPrivate.h DigitalOutputPrivate.h EncAlignCtrlPrivate.h MCIRQHandlerPrivate.h MotorPowerMeasurementPrivate.h PID_PIRegulatorPrivate.h PIRegulatorPrivate.h PQD_MotorPowerMeasurementPrivate.h PWMnCurrFdbkPrivate.h SpeednPosFdbkPrivate.h SpeednTorqCtrlPrivate.h StateMachinePrivate.h TemperatureSensorPrivate.h Virtual_BusVoltageSensorPrivate.h Virtual_TemperatureSensorPrivate.h VirtualSpeedSensor_SpeednPosFdbkPrivate.h R1_F30X_PWMnCurrFdbkPrivate.h R3_1_F30X_PWMnCurrFdbkPrivate.h R3_2_F30X_PWMnCurrFdbkPrivate.h R3_4_F30X_PWMnCurrFdbkPrivate.h ICS_F30X_PWMnCurrFdbkPrivate.h ENC_F30X_SpeednPosFdbkPrivate.h HALL_F30X_SpeednPosFdbkPrivate.h DigitalOutputClass_F30XPrivate.h Rdivider_F30X_BusVoltageSensorPrivate.h NTC_F30X_TemperatureSensorPrivate.h CircleLimitationPrivate.h OpenLoopPrivate.h HiFreqInj_FPU_SpeednPosFdbkPrivate.h RampExtMngrPrivate.h RampMngrPrivate.h
  group MCLibrary_src
    ../../MCLibrary/src/: BusVoltageSensorClass.c EncAlignCtrlClass.c MC_Math.c MCIRQHandlerClass.c MotorPowerMeasurementClass.c PID_PIRegulatorClass.c PIRegulatorClass.c PQD_MotorPowerMeasurementClass.c PWMnCurrFdbkClass.c SpeednPosFdbkClass.c SpeednTorqCtrlClass.c StateMachineClass.c TemperatureSensorClass.c Virtual_BusVoltageSensorClass.c Virtual_TemperatureSensorClass.c VirtualSpeedSensor_SpeednPosFdbkClass.c R1_F30X_PWMnCurrFdbkClass.c R3_1_F30X_PWMnCurrFdbkClass.c R3_2_F30X_PWMnCurrFdbkClass.c R3_4_F30X_PWMnCurrFdbkClass.c ICS_F30X_PWMnCurrFdbkClass.c InrushCurrentLimiterClass.c ENC_F30X_SpeednPosFdbkClass.c HALL_F30X_SpeednPosFdbkClass.c DigitalOutputClass_F30X.c RampExtMngrClass.c RampMngrClass.c Rdivider_F30X_BusVoltageSensorClass.c NTC_F30X_TemperatureSensorClass.c CircleLimitationClass.c OpenLoopClass.c HiFreqInj_FPU_SpeednPosFdbkClass.c GAP_F3xx_GateDriverCtrlClass.c GAP_GateDriverCtrlClass.c GateDriverCtrlClass.c
  group MCLibrary_conf
    ../../MCLibrary/: MCLibraryConf.h stm32f30x_MisraCompliance.h
  group MCLibrary_lib_single
    ./MC_Library_Compiled/RVMDK_MCLIB_OBJS_SINGLE/: MC_Library_ProtectedSources_SD_CM4_CCM_MKD.lib MC_Library_ProtectedSources_single_drive_CM4_MKD.lib
  group MCLibrary_lib_dual
    ./MC_Library_Compiled/RVMDK_MCLIB_OBJS_DUAL/: MC_Library_ProtectedSources_DD_CM4_CCM_MKD.lib MC_Library_ProtectedSources_dual_drive_CM4_MKD.lib
target STM32F303_Dual_Drive (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: as above
  output: MC_Library_STM32F303_dual_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X, MC_LIBRARY_DUAL, ARM_MATH_CM4, CCMRAM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
target STM32F302 Single Drive (ARM-ADS)
  device: STM32F302VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: MC_Library_STM32F302_single_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X, MC_LIBRARY_SINGLE, ARM_MATH_CM4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target STM32F302x8_Single_Drive (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F302C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MC_Library_STM32F302x8_single_drive (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X, MC_LIBRARY_SINGLE, ARM_MATH_CM4, STM32F302x8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
