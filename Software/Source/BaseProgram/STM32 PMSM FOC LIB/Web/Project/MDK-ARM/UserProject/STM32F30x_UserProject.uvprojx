# Keil uVision project STM32F30x_UserProject.uvprojx, settings and files
target STM32303C-EVAL_SINGLEDRIVE (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32303C-EVAL_SINGLEDRIVE
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X, USE_STM32303C_EVAL, ARM_MATH_CM4, CCMRAM, STM32F303X
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F30x\Include;..\..\..\..\Common\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM32303C_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: ..\sct\STM32F303x.sct
  group MCLibrary_interface_common
    ../../../MCLibrary/interface/common/: DigitalOutputClass.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group MCLibrary_interface
    ../../../MCLibrary/interface/: BusVoltageSensorClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h HALL_F30X_SpeednPosFdbkClass.h ICS_DD_PWMnCurrFdbkClass.h ICS_F30X_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h NTC_TemperatureSensorClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_DD_PWMnCurrFdbkClass.h R1_F30X_PWMnCurrFdbkClass.h R3_1_F30X_PWMnCurrFdbkClass.h R3_2_F30X_PWMnCurrFdbkClass.h R3_4_F30X_PWMnCurrFdbkClass.h R3_DD_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h CircleLimitationClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h MTPACtrlClass.h OpenLoopClass.h
  group MCLibrary_lib
    ../MC_Library_Compiled/STM32F302_SD/: MC_Library_STM32F302_single_drive.lib
    ../MC_Library_Compiled/STM32F303_SD/: MC_Library_STM32F303_single_drive.lib
    ../MC_Library_Compiled/STM32F303_DD/: MC_Library_STM32F303_dual_drive.lib
    ../MC_Library_Compiled/STM32F302x8_SD/: MC_Library_STM32F302x8_single_drive.lib
  group MCApplication_interface
    ../../../MCApplication/interface/: MCInterfaceClass.h MCTasks.h MCTuningClass.h MC.h
  group MCApplication_private
    ../../../MCApplication/inc/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTuningClassPrivate.h MCTuningPrivate.h
  group MCApplication_src
    ../../../MCApplication/src/: MCInterfaceClass.c MCTasks.c MCTuningClass.c
  group CMSIS
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df2T_f32.c
  group StdPeriph_Driver
    ../../../../Common/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group STM32_EVAL
    ../../../../Common/Libraries/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.h stm32303c_eval.c stm32303c_eval_lcd.h stm32303c_eval_lcd.c
  group RVMDK
    ../../../../Common/Libraries/CMSIS/CMSIS_2_x/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f302.s startup_stm32f303.s
  group UILibrary_interface
    ../../../UILibrary/interface/: DAC_F30X_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h LCDVintage_UserInterfaceClass.h UnidirectionalFastCom_UserInterfaceClass.h
  group UILibrary_private
    ../../../UILibrary/inc/: DAC_F30X_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCD_Interface.h LCDManager_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h UnidirectionalFastCom_UserInterfacePrivate.h
  group UILibrary_src
    ../../../UILibrary/src/: FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c UserInterfaceClass.c DAC_F30X_UserInterfaceClass.c USART_F30X_PhysicalLayerCommunication_Class.c LCDVintage_UserInterfaceClass.c UnidirectionalFastCom_F3XX_UserInterfaceClass.c
  group Project
    ../../: UITask.c main.c Timebase.c stm32f30x_it.c GAPApplication.c
    ../../../SystemDriveParams/: stm32f30x_MC_it.c
  group System & Drive Params
    ../../../SystemDriveParams/: Control stage parameters motor 2.h Control stage parameters.h Drive parameters motor 2.h Drive parameters.h Parameters conversion motor 2.h Parameters conversion.h Parameters conversion_F30x motor 2.h Parameters conversion_F30x.h PMSM motor 2 parameters.h PMSM motor parameters.h Power stage parameters motor 2.h Power stage parameters.h SystemNDriveParams.h
  group Doc
    ./: readme.txt
  group ApplicationProgram
    ../../../../../../ApplicationProgram/: globals.h pi_controller.c application.h application.c time.c time.h types.h local_io.c local_io.h pi_controller.h motor.c motor.h
target STM32303C-EVAL_DUALDRIVE (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: as above
  output: STM32303C-EVAL_DUALDRIVE
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: ..\sct\STM32F303x.sct
target STM32F302_SINGLEDRIVE (ARM-ADS)
  device: STM32F302VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: STM32F302_SINGLEDRIVE
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F30X, USE_STM32303C_EVAL, ARM_MATH_CM4, STM32F302X
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target P-NUCLEO-IHM001_SINGLEDRIVE (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F302C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F302x8_SINGLEDRIVE_RDB_Diplomaterv_EXE +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F30X, P_NUCLEO_IHM001, ARM_MATH_CM4
  c include: ..\..\;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Include;..\..\..\..\Common\Libraries\CMSIS\CMSIS_2_x\Device\ST\STM32F30x\Include;..\..\..\..\Common\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\..\Common\Libraries\STM32_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\STM32303C_EVAL;..\..\..\..\Common\Libraries\STM32_EVAL\Common;..\..\..\MCApplication\interface;..\..\..\MCApplication\inc\;..\..\..\MCLibrary\interface\common;..\..\..\MCLibrary\interface\;..\..\..\UILibrary\interface;..\..\..\UILibrary\inc;..\..\..\SystemDriveParams;..\..\..\..\..\..\..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
